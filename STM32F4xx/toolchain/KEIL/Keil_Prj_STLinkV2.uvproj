# Keil uVision project Keil_Prj_STLinkV2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Keil_Prj
  c flags: Optim=1
  c define: ARM_MATH_CM4 STM32F4XX USE_STDPERIPH_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\STM32F4xxx.sct
